Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:46+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SND-06
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Песочница, ZSK-SND-06 Песочница-самолёт «Турбо»
In: Площадка
Description: Песочница. Песочница-самолёт «Турбо»; Classification: 59.1.15.01-0951 Песочница (Классификатор строительных ресурсов (КСР)); Material: влагостойкая фанера 21 мм с УФ-печатью под лаком, опоры — ст
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SND-06; ModelReference: Песочница-самолёт «Турбо»; ProductionYear: 2026; ArticleNumber: ZSK-SND-06
ORION_Изделие - Артикул: ZSK-SND-06; Артикул прежний: SD-SND-06; Наименование: Песочница-самолёт «Турбо»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 4000×3600×1000 мм; Возраст: 1–8 лет; Материал: влагостойкая фанера 21 мм с УФ-печатью под лаком, опоры — сталь с порошковой окраской; Цена: от 390 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/sandboxes/21006; Код КСИ: CPr>EDB180; Класс КСИ: Песочница; Коды КСР: 59.1.15.01-0951 … 59.1.15.01-1014
ADSK - ADSK_Наименование: Песочница-самолёт «Турбо»; ADSK_Марка: ZSK-SND-06; ADSK_Код изделия: 59.1.15.01-0951; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: влагостойкая фанера 21 мм с УФ-печатью под лаком, опоры — сталь с порошковой окраской; ADSK_URL страницы изделия: https://зск.рф/catalog/sandboxes/21006
ZSK_Благоустройство - ZSK_Возрастная_группа: 1–8 лет; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB180; ZSK_Артикул_прежний: SD-SND-06
Qto_ORION - Длина: 4000 mm; Ширина: 3600 mm; Высота: 1000 mm
